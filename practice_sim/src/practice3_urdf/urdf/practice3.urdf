Commit message: update

File: practice_sim/src/practice3_urdf/urdf/practice3.urdf (robot description, URDF)
Before this commit: robot practice3, 9 links, 8 joints
Joints:
- joint R_Wheel_Joint: axis 0 0 0 -> 0 0.577491348313505 -0.816396804637947
